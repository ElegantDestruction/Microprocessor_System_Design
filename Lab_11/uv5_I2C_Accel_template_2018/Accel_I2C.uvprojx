# Keil uVision project Accel_I2C.uvprojx, settings and files
target CMSIS-DAP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Accel_I2C
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./source/: uv5_I2C_main.c i2c.c LEDs.c mma8451.c GPIO_defs.h i2c.h LEDs.h mma8451.h delay.c delay.h
software components: CMSIS:CORE 4.3.0, Device:Startup 2.5.0
